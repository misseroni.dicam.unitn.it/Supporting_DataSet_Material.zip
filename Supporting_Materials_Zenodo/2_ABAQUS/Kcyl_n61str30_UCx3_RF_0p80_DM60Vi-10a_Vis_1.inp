*Heading
** Job name: Kcyl_n61str30_UCx3_th075wh150thd125_rm_fix_vi_DM60Vi-10a_Vis_1 Model name: Kcyl_UC_th075wh150thd125-eq-X3-Visc
** Generated by: Abaqus/CAE 2021
*Preprint, echo=NO, model=NO, history=NO, contact=NO
**
** PARTS
**
*Part, name=Kcyl_n6UC_th075wh150thd125_eq_OP
*Node
      1,   -21.954195,   50.4775276,  -14.3305531
      2,  -24.2200203,   50.4775276,  -15.5781527
      3,  -28.4093189,   5.04838657,  -3.31176019
      4,  -25.8090553,   5.46506643,  -3.28904009
      5,  -20.8914509,   50.4775276,   -14.944128
      6,  -23.0258102,   50.4775276,  -16.2676296
      7,  -19.8287067,   50.4775276,   -15.557704
      8,  -21.8316021,   50.4775276,  -16.9571056
      9,  -17.7032185,   50.4775276,  -16.7848549
     10,  -19.4431858,   50.4775276,  -18.3360596
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*Element, type=C3D10MH
   1,  9659,  9660,  2434,  2561, 12391, 12390, 12389, 12393, 12392, 12394
   2,  9659,  9661,  2740,  9662, 12397, 12396, 12395, 12399, 12398, 12400
   3,  9659,  9660,  9663,   213, 12391, 12402, 12401, 12404, 12403, 12405
   4,  9659,  2406,  9661,  9662, 12407, 12406, 12397, 12399, 12408, 12398
   5,  9659,  2407,  9661,  2406, 12410, 12409, 12397, 12407, 12411, 12406
   6,  9664,  9665,  2483,  2485, 12414, 12413, 12412, 12416, 12415, 12417
   7,  9664,  2792,  9666,  2763, 12420, 12419, 12418, 12422, 12421, 12423
   8,  9664,  9665,  2738,  2791, 12414, 12425, 12424, 12427, 12426, 12428
   9,  9664,  9665,  9667,  2738, 12414, 12430, 12429, 12424, 12425, 12431
  10,  9668,  2515,  9669,  2512, 12434, 12433, 12432, 12436, 12435, 12437
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*Nset, nset=Set-1, generate
     1,  76560,      1
*Elset, elset=Set-1, generate
     1,  42162,      1
*Nset, nset="Edge Seeds-OP"
     1,     2,     3,     4,    12,    13,    15,    16,    17,    18,    26,    27,    29,    30,    31,    32
    40,    41,    45,    46,    47,    48,    49,    50,    59,    60,    61,    62,    63,    64,    73,    74
    75,    76,    77,    78,    87,    88,    89,    90,    91,    92,   101,   102,   103,   104,   105,   106
   115,   116,   117,   118,   119,   120,   127,   128,   129,   130,   138,   139,   141,   142,   143,   144
   152,   153,   155,   156,   157,   158,   166,   167,   169,   170,   202,   203,   291,   292,   343,   344
   376,   377,   465,   466,   517,   518,   550,   551,   639,   640,   700,   701,   747,   748,   787,   788
   874,   875,   921,   922,   961,   962,  1048,  1049,  1095,  1096,  1135,  1136,  1222,  1223,  1269,  1270
  1309,  1310,  1396,  1397,  1443,  1444,  1483,  1484,  1570,  1571,  1617,  1618,  1657,  1658,  1735,  1736
  1768,  1769,  1857,  1858,  1909,  1910,  1942,  1943,  2031,  2032,  2083,  2084,  2116,  2117,  2205,  2206
 13687, 16433, 16769, 16772, 17552, 17557, 17764, 17872, 17906, 22352, 22353, 22363, 23015, 23155, 23375, 23479
 23493, 23503, 24362, 27851, 27960, 27983, 27999, 28748, 28983, 28990, 29115, 29383, 33147, 33481, 33497, 33611
 34065, 34071, 34173, 34292, 35333, 38320, 38566, 38578, 39087, 39091, 39281, 39301, 39374, 39685, 41735, 43456
 43527, 43732, 43733, 43794, 44390, 44504, 48794, 48814, 48820, 48872, 49349, 49356, 49470, 49478, 49497, 49823
 53572, 53626, 53959, 53961, 54106, 54528, 54615, 54745, 55603, 59033, 59049, 59066, 59538, 59700, 59728, 59745
 59823, 60913, 64236, 64238, 64241, 64965, 64994, 65223, 65345, 65355, 66222, 66297, 69751, 69768, 70574, 70781
 70789, 70890, 70915, 71507, 71545, 75363, 75377, 76133, 76137, 76274, 76358, 76499
*Elset, elset="Edge Seeds-OP"
   316,  1468,  1653,  1819,  1822,  2494,  2669,  2679,  2785,  3006,  3234,  3296,  5501,  5509,  5517,  5527
  6144,  6229,  6356,  6374,  6674,  6911,  6942,  6976,  7590,  9097,  9176,  9208,  9225,  9932, 10037, 10107
 10176, 10401, 10404, 10717, 11156, 11205, 12721, 13076, 13086, 13245, 14011, 14014, 14163, 14210, 14224, 14304
 14417, 14708, 14737, 16189, 16451, 16461, 17216, 17218, 17547, 17572, 17599, 17609, 17615, 17709, 17842, 17856
 18437, 19472, 19534, 19764, 19765, 19869, 20621, 20623, 20845, 20872, 21079, 23091, 23119, 23126, 23190, 23980
 23982, 24157, 24176, 24187, 24239, 24240, 24251, 24497, 24518, 26059, 26108, 26400, 26403, 26584, 27345, 27347
 27462, 27491, 27519, 27786, 27996, 28021, 29776, 29798, 29815, 30569, 30818, 30874, 30898, 30913, 30926, 30981
 31036, 31371, 31412, 32907, 32913, 32920, 33612, 33698, 33732, 33761, 33846, 34073, 34340, 34368, 34987, 35008
 36622, 36645, 37287, 37450, 37507, 37583, 37795, 37798, 38008, 38049, 38604, 38615, 38653, 40284, 40296, 40303
 40984, 41134, 41143, 41174, 41317, 41449, 41801
** Section: OP
*Solid Section, elset=Set-1, material=VeroBlack_exp2_ELPL
,
*End Part
**
*Part, name=Kcyl_n6UC_th075wh150thd125_eq_P
*Node
      1,  -23.1173878,   45.9775276,   15.3679533
      2,  -22.4846821,   45.9775276,   14.9470406
      3,  -22.6244526,   45.9775276,   12.7344875
      4,  -24.7562675,   45.9775276,   14.1523104
      5,  -24.7310944,   45.9775276,    14.567874
      6,  -23.0047626,   45.9775276,   17.1655884
      7,  -22.6305218,   45.9775276,    17.349453
      8,  -20.4986725,   45.9775276,   15.9322662
      9,  -14.9470406,    6.5224719,   22.4846821
     10,  -15.9322672,    6.5224719,   20.4986744
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*Element, type=C3D10MH
   1,  6641,  6642,   206,  2956,  8274,  8273,  8272,  8276,  8275,  8277
   2,  6641,  2798,  6642,  6643,  8279,  8278,  8274,  8281,  8280,  8282
   3,  6641,  6644,  6645,  6643,  8285,  8284,  8283,  8281,  8286,  8287
   4,  6641,  6642,  6644,  6643,  8274,  8288,  8285,  8281,  8282,  8286
   5,  6641,  6646,  6643,  6645,  8290,  8289,  8281,  8283,  8291,  8287
   6,  6647,  6648,  6649,  6650,  8294,  8293,  8292,  8296,  8295,  8297
   7,  6647,  6651,  6649,  6648,  8299,  8298,  8292,  8294,  8300,  8293
   8,  6647,  2849,  6649,  2852,  8302,  8301,  8292,  8304,  8303,  8305
   9,  6651,  6652,  2976,  6653,  8308,  8307,  8306,  8310,  8309,  8311
  10,  6651,  6648,  2974,  6649,  8300,  8313,  8312,  8298,  8293,  8314
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*Nset, nset=Set-1, generate
     1,  50897,      1
*Elset, elset=Set-1, generate
     1,  27733,      1
*Nset, nset="Edge Seeds-P"
     1,     2,     9,    13,    17,    18,    25,    29,    33,    34,    41,    45,    49,    50,    57,    61
    65,    66,    73,    78,    81,    82,    89,    94,    97,    98,   491,   492,   493,   494,   887,   888
   889,   890,  1283,  1284,  1285,  1286,  1679,  1680,  1681,  1682,  2030,  2031,  2032,  2033,  2381,  2382
  8458,  9084,  9091, 13133, 13136, 13158, 15665, 17680, 20070, 20089, 20167, 21333, 22375, 23874, 24609, 25711
 27022, 28447, 31158, 31826, 32680, 33860, 33934, 35041, 36176, 36189, 36210, 36230, 37013, 41224, 43666, 43690
 43788, 47171, 47504, 48759
*Elset, elset="Edge Seeds-P"
    42,   185,  1189,  1596,  1850,  1851,  1862,  1928,  1952,  2044,  2998,  3681,  5143,  6341,  6353,  6366
  6412,  6463,  7404,  7481,  7490,  7503,  8046,  8748,  9417,  9634, 10748, 10828, 10883, 10906, 10942, 11027
 11922, 11945, 12353, 12555, 14030, 14583, 15090, 15316, 15323, 15375, 15510, 16388, 16407, 17108, 17321, 17322
 18049, 19761, 19872, 19933, 19934, 20041, 20048, 21136, 21173, 21205, 22621, 22725, 22917, 22943, 23935, 24067
 24733, 24769, 24796, 24797, 24919, 25926, 27128, 27475
*Nset, nset="Edge Seeds-P-edge"
     3,     4,     7,     8,    10,    11,    15,    16,    19,    20,    23,    24,    26,    27,    31,    32
    35,    36,    39,    40,    42,    43,    47,    48,    51,    52,    55,    56,    58,    59,    63,    64
    67,    68,    71,    72,    74,    75,    79,    80,    83,    84,    87,    88,    90,    91,    95,    96
   101,   102,   103,   110,   111,   112,   207,   208,   209,   441,   442,   443,   497,   498,   499,   506
   507,   508,   603,   604,   605,   837,   838,   839,   893,   894,   895,   902,   903,   904,   999,  1000
  1001,  1233,  1234,  1235,  1289,  1290,  1291,  1298,  1299,  1300,  1395,  1396,  1397,  1629,  1630,  1631
  1685,  1686,  1687,  1694,  1695,  1696,  1791,  1792,  1793,  1980,  1981,  1982,  2036,  2037,  2038,  2045
  2046,  2047,  2142,  2143,  2144,  2331,  2332,  2333,  8371, 10318, 11868, 11913, 12379, 12795, 13143, 13156
 13231, 13415, 13509, 14374, 14389, 14420, 14461, 14620, 15203, 17236, 19326, 19583, 19696, 19739, 19913, 20073
 20104, 20180, 20199, 20367, 21272, 21281, 21298, 21336, 22954, 24710, 25545, 26513, 26638, 27050, 27122, 27209
 27260, 27274, 28210, 28231, 28242, 28244, 28335, 28338, 29171, 32644, 32733, 33076, 33570, 33652, 33874, 33928
 33956, 34080, 34164, 35065, 35140, 35154, 35155, 35228, 36096, 36164, 37605, 38135, 41256, 41289, 41291, 41382
 41392, 41409, 41452, 41465, 41890, 41895, 43338, 43341, 43560, 43591, 43694, 43732, 43890, 45739, 45777, 46584
 48757, 48802, 48809, 48948, 49388, 49402, 50795, 50801
*Elset, elset="Edge Seeds-P-edge"
    22,   512,  1086,  1109,  1365,  1604,  1630,  1854,  1861,  1901,  1929,  1986,  2007,  2008,  2074,  2165
  2924,  2936,  2939,  2964,  3011,  3142,  3169,  3289,  3735,  4319,  4427,  4498,  5007,  5863,  6022,  6082
  6114,  6228,  6343,  6358,  6404,  6422,  6432,  6495,  6518,  6561,  6568,  6592,  7318,  7451,  7454,  7455
  7473,  7504,  7630,  8219,  8794,  8935,  9184,  9668,  9996, 10515, 10592, 10621, 10884, 10908, 10970, 11040
 11046, 11088, 11101, 11162, 11957, 11958, 11962, 11984, 11998, 12000, 12095, 12123, 12131, 13430, 13433, 13479
 13518, 14569, 14615, 14789, 15121, 15185, 15329, 15330, 15371, 15376, 15400, 15450, 15494, 15502, 15512, 15561
 16424, 16501, 16513, 16515, 16520, 16557, 16584, 16642, 16713, 17944, 18020, 18037, 18378, 18530, 19894, 19895
 19901, 19917, 19918, 19989, 19999, 20014, 20042, 20058, 20073, 20406, 20418, 20422, 20426, 20434, 21298, 21309
 21311, 22244, 22250, 22281, 22307, 22345, 22893, 22900, 22923, 22930, 22965, 23432, 23443, 23721, 24767, 24777
 24782, 24804, 24810, 24861, 24930, 24934, 24948, 25282, 25290, 25295, 25300, 25306, 27127, 27141, 27202, 27209
 27212, 27213
*Nset, nset="Edge Seeds-P-circ"
     1,     5,     6,    12,    13,    14,    17,    21,    22,    28,    29,    30,    33,    37,    38,    44
    45,    46,    49,    53,    54,    60,    61,    62,    65,    69,    70,    76,    77,    78,    81,    85
    86,    92,    93,    94,   104,   105,   106,   107,   108,   109,   345,   346,   347,   348,   349,   350
   500,   501,   502,   503,   504,   505,   741,   742,   743,   744,   745,   746,   896,   897,   898,   899
   900,   901,  1137,  1138,  1139,  1140,  1141,  1142,  1292,  1293,  1294,  1295,  1296,  1297,  1533,  1534
  1535,  1536,  1537,  1538,  1688,  1689,  1690,  1691,  1692,  1693,  1929,  1930,  1931,  1932,  1933,  1934
  2039,  2040,  2041,  2042,  2043,  2044,  2280,  2281,  2282,  2283,  2284,  2285,  8616,  8629,  9182, 12064
 12065, 12654, 12655, 12758, 13166, 13274, 14416, 14417, 14444, 14450, 14462, 14724, 16019, 16119, 17993, 17999
 18985, 18989, 19572, 19573, 20094, 20106, 20211, 20246, 21297, 21301, 21320, 21326, 23063, 24945, 25902, 25903
 26447, 26510, 26515, 26628, 26905, 27034, 27096, 27141, 27146, 27178, 28197, 28251, 29409, 29605, 29919, 29927
 32338, 32678, 33429, 33673, 33800, 33865, 33898, 34049, 35054, 35160, 35454, 35458, 36269, 37016, 37364, 37662
 38792, 38807, 39296, 39719, 41059, 41078, 41250, 41286, 41428, 42795, 43386, 43404, 43705, 43713, 43733, 43747
 44055, 45871, 46090, 46518, 47176, 47241, 47505, 47907, 48230, 48417, 48740, 50845
*Elset, elset="Edge Seeds-P-circ"
    75,    79,   208,   713,  1188,  1189,  1528,  1532,  1596,  1605,  1869,  1871,  1872,  1955,  2959,  2960
  2973,  2989,  2997,  3004,  3013,  3529,  3533,  4366,  4680,  4705,  5256,  5259,  5680,  5682,  6011,  6013
  6341,  6354,  6360,  6372,  6374,  6443,  6453,  6469,  7307,  7468,  7476,  7494,  7497,  7975,  8043,  8046
  8850,  8865,  9212,  9757, 10158, 10161, 10466, 10514, 10516, 10582, 10593, 10748, 10768, 10835, 10850, 10895
 10942, 10981, 10987, 11016, 11052, 11926, 11944, 12007, 12024, 12497, 13325, 13570, 13615, 13690, 13691, 13692
 14438, 14583, 15016, 15095, 15201, 15277, 15324, 15337, 15349, 15474, 16392, 16417, 16521, 16529, 16576, 17037
 17109, 17127, 17794, 17962, 18062, 18235, 18314, 18398, 18731, 18742, 18914, 19072, 19757, 19774, 19782, 19803
 19877, 19880, 19890, 19916, 19934, 20029, 20056, 20064, 20079, 21173, 21550, 22487, 22491, 22603, 22610, 22623
 22714, 22721, 22925, 22927, 22931, 22934, 22999, 23483, 23560, 23689, 23936, 23958, 24067, 24290, 24330, 24484
 24579, 24584, 24739, 24750, 24772, 24789, 24832, 24927, 24935, 24949, 27142, 27144, 27169, 27465, 27469, 27477
** Section: P
*Solid Section, elset=Set-1, material=DM60_exp1_Hyp1-Vi-10a
,
*End Part
**
*Part, name=Kcyl_n6UC_th075wh150thd125_eq_f
*Node
      1,   -21.954195,   50.4775276,  -14.3305531
      2,  -4.95029259,   50.4775276,  -24.1477604
      3,  -4.01318741,         52.5,  -25.0849094
      4,  -21.7822056,         52.5,  -14.8259621
      5,  -4.03205204,         52.5,  -25.8713589
      6,  -22.4726639,         52.5,  -15.2246675
      7,  -24.1936092,   50.7612839,  -15.6549101
      8,  -24.2200203,   50.4775276,  -15.5781527
      9,  -5.11268377,   50.4775276,  -26.6097775
     10,   -4.9671855,   50.7612839,   -26.755291
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*Element, type=C3D10MH
  1, 3625, 1704, 3626, 1682, 4035, 4034, 4033, 4037, 4036, 4038
  2, 3625,  180, 1818,  181, 4041, 4040, 4039, 4043, 4042, 4044
  3, 3625, 1795, 3626, 1819, 4046, 4045, 4033, 4048, 4047, 4049
  4, 3625, 1818,  180,  155, 4039, 4040, 4041, 4051, 4050, 4052
  5, 3625, 1819,  156,  181, 4048, 4054, 4053, 4043, 4055, 4056
  6, 3625, 1819, 1704,  156, 4048, 4057, 4035, 4053, 4054, 4058
  7, 3625, 1818,  155, 1705, 4039, 4050, 4051, 4060, 4059, 4061
  8, 3627, 1811, 1810, 1787, 4064, 4063, 4062, 4066, 4065, 4067
  9, 3627, 1811, 1713, 1810, 4064, 4069, 4068, 4062, 4063, 4070
 10, 3627, 3628, 1788, 3629, 4073, 4072, 4071, 4075, 4074, 4076
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*Nset, nset=Set-1, generate
     1,  23020,      1
*Elset, elset=Set-1, generate
     1,  11368,      1
*Nset, nset="Edge Seeds-f_circ"
     5,     6,     7,    10,    15,    16,    17,    20,    25,    26,    27,    30,    37,    38,    39,    40
    47,    48,    49,    50,    57,    58,    59,    60,    67,    68,    69,    70,    77,    78,    79,    80
    87,    88,    89,    90,    95,    96,    97,   100,   105,   106,   107,   110,   115,   116,   117,   120
   194,   195,   196,   224,   225,   226,   323,   324,   325,   353,   354,   355,   452,   453,   454,   482
   483,   484,   608,   609,   610,   634,   635,   636,   737,   738,   739,   763,   764,   765,   866,   867
   868,   892,   893,   894,   995,   996,   997,  1021,  1022,  1023,  1124,  1125,  1126,  1150,  1151,  1152
  1253,  1254,  1255,  1279,  1280,  1281,  1355,  1356,  1357,  1385,  1386,  1387,  1484,  1485,  1486,  1514
  1515,  1516,  1613,  1614,  1615,  1643,  1644,  1645,  4308,  4805,  4916,  5086,  5353,  5402,  5457,  5468
  5896,  6397,  6512,  6667,  6923,  7043,  7054,  7055,  7960,  8081,  8252,  8501,  8606,  8608,  8616,  8677
  9039, 10029, 10031, 10041, 10085, 10102, 10121, 10145, 11068, 11130, 11492, 11617, 11619, 11633, 11677, 11755
 12215, 12446, 12932, 13211, 13213, 13223, 13266, 13312, 13803, 14091, 14650, 14824, 14825, 14836, 14882, 14934
 15380, 15562, 16092, 16399, 16401, 16412, 16485, 16527, 16978, 17376, 17751, 17980, 17982, 17994, 18051, 18248
 18708, 19072, 19193, 19598, 19646, 19670, 19718, 19730, 20639, 20910, 21176, 21181, 21232, 21293, 21304, 21365
 21759, 21887, 22234, 22344, 22489, 22746, 22869, 22878
*Elset, elset="Edge Seeds-f_circ"
    65,   153,   224,   286,   378,   532,   596,   682,   692,   698,  1006,  1012,  1168,  1222,  1313,  1465
  1628,  1643,  1644,  1874,  2110,  2175,  2273,  2417,  2566,  2567,  2572,  2581,  2636,  2685,  2892,  3314
  3315,  3326,  3366,  3372,  3385,  3413,  3414,  3593,  3988,  4019,  4199,  4259,  4260,  4272,  4307,  4361
  4510,  4553,  4796,  4864,  5059,  5210,  5211,  5223,  5266,  5268,  5315,  5342,  5749,  5830,  6085,  6178
  6179,  6191,  6227,  6245,  6276,  6277,  6700,  6748,  6964,  7123,  7124,  7134,  7186,  7230,  7231,  7520
  7652,  7772,  7951,  8067,  8068,  8079,  8132,  8330,  8403,  8420,  8644,  8695,  8767,  8829,  9064,  9119
  9144,  9221,  9236,  9469,  9708,  9861, 10011, 10013, 10077, 10174, 10178, 10188, 10246, 10292, 10499, 10521
 10533, 10654, 10709, 10802, 10945, 11108, 11125, 11360
*Nset, nset="Edge Seeds-f-edge"
     1,     2,     3,     4,    11,    12,    13,    14,    21,    22,    23,    24,    31,    32,    33,    34
    41,    42,    43,    44,    51,    52,    53,    54,    61,    62,    63,    64,    71,    72,    73,    74
    81,    82,    83,    84,    91,    92,    93,    94,   101,   102,   103,   104,   111,   112,   113,   114
   144,   145,   169,   170,   273,   274,   298,   299,   402,   403,   427,   428,   531,   532,   556,   557
   660,   661,   685,   686,   789,   790,   814,   815,   918,   919,   943,   944,  1047,  1048,  1072,  1073
  1176,  1177,  1201,  1202,  1305,  1306,  1330,  1331,  1434,  1435,  1459,  1460,  1563,  1564,  1588,  1589
  4115,  4228,  4261,  4921,  5062,  5113,  5668,  5831,  6389,  6518,  6636,  6976,  7419,  7716,  7774,  7994
  8219,  8596,  9142,  9247,  9450, 10113, 10149, 10251, 10612, 10834, 11601, 11718, 11767, 11886, 12393, 12418
 12429, 13371, 13431, 13437, 13806, 14811, 14920, 14936, 15011, 15049, 15571, 15598, 16330, 16381, 16414, 16455
 17177, 17185, 17998, 18045, 18057, 18203, 18530, 18574, 18595, 18664, 19319, 19654, 20099, 20333, 20468, 20750
 20881, 21230, 21501, 21675, 22229, 22349, 22461, 22808
*Elset, elset="Edge Seeds-f-edge"
    19,    45,    52,   289,   370,   385,   502,   585,   647,   697,   762,   858,   955,   991,  1164,  1225
  1303,  1485,  1525,  1598,  1642,  1702,  1881,  1884,  1936,  2021,  2039,  2120,  2178,  2263,  2435,  2437
  2548,  2580,  2623,  2635,  2921,  2951,  3022,  3360,  3378,  3416,  3456,  3548,  3561,  3607,  3689,  3778
  3843,  3905,  4255,  4306,  4327,  4380,  4400,  4405,  4496,  4576,  4659,  4699,  4845,  4853,  4859,  4979
  5256,  5356,  5358,  5465,  5475,  5525,  5597,  5664,  5750,  6174,  6226,  6256,  6278,  6332,  6377,  6409
  6419,  6421,  6473,  6561,  6752,  6762,  7092,  7118,  7135,  7167,  7170,  7269,  7271,  7374,  7512,  7519
  7707,  7710,  8084,  8119,  8126,  8138,  8215,  8257,  8310,  8328,  8410,  8446,  8596,  8607,  8614,  8634
  8832,  8914,  9123,  9161,  9227,  9235,  9298,  9389,  9536,  9597,  9635,  9773,  9852,  9984, 10012, 10073
 10114, 10187, 10247, 10347, 10439, 10476, 10652, 10712, 10794, 10965, 11007, 11124, 11127, 11238, 11315, 11365
** Section: f
*Solid Section, elset=Set-1, material=DM60_exp1_Hyp1-Vi-10a
,
*End Part
**
*Part, name=Kcyl_n6UC_th075wh150thd125_eq_v
*Node
      1,  -3.31370687,   47.4444046,  -28.4086533
      2,  -3.28906417,   47.0348816,  -25.8090324
      3,  -25.0849094,           0.,  -4.01318741
      4,  -13.7031622,      27.1875,  -18.0191975
      5,   -27.647213,           0.,  -4.07514763
      6,  -2.82523513,    48.925869,   -25.970932
      7,  -25.4973564,           0.,  -3.29880738
      8,  -27.6573467,           0.,  -1.94858718
      9,      -28.875,           0.,  -1.94855714
     10,  -14.9309492,      27.1875,  -15.8926077
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*Element, type=C3D10MH
   1,  4053,   451,   525,  3701,  9794,  9793,  9792,  9796,  9795,  9797
   2,  4053,  3701,   525,  8185,  9796,  9797,  9792,  9799,  9798,  9800
   3,  8185,  8186,  4056,  8187,  9803,  9802,  9801,  9805,  9804,  9806
   4,  8185,  8186,  8187,  3704,  9803,  9804,  9805,  9808,  9807,  9809
   5,  8185,  8188,  3701,  8189,  9811,  9810,  9798,  9813,  9812,  9814
   6,  3510,  8190,  8191,  8192,  9817,  9816,  9815,  9819,  9818,  9820
   7,  4055,   526,  8186,  8185,  9823,  9822,  9821,  9825,  9824,  9803
   8,  8193,  8194,  3961,  3997,  9828,  9827,  9826,  9830,  9829,  9831
   9,  8193,  3998,   646,  3960,  9834,  9833,  9832,  9836,  9835,  9837
  10,  8193,  8195,  3615,  3998,  9840,  9839,  9838,  9834,  9841,  9842
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*Nset, nset=Set-1, generate
     1,  59140,      1
*Elset, elset=Set-1, generate
     1,  31392,      1
*Nset, nset="Edge Seeds-v_circ"
     7,     8,    12,    13,    26,    27,    31,    32,    45,    46,    50,    51,    64,    65,    69,    70
    83,    84,    88,    89,   102,   103,   107,   108,   325,   326,   327,   421,   422,   423,   860,   861
   862,   956,   957,   958,  1395,  1396,  1397,  1491,  1492,  1493,  1930,  1931,  1932,  2026,  2027,  2028
  2465,  2466,  2467,  2561,  2562,  2563,  3000,  3001,  3002,  3096,  3097,  3098, 11041, 16347, 16948, 17119
 17146, 17188, 17533, 17948, 19677, 24544, 25198, 25201, 25381, 25414, 25452, 26091, 28663, 32826, 33460, 33620
 33653, 33686, 34318, 34410, 35696, 41021, 41622, 41633, 41801, 41845, 42517, 42637, 42716, 44366, 49879, 49882
 50016, 50045, 50448, 50746, 53534, 57488, 58107, 58109, 58251, 58288, 58312, 59095
*Elset, elset="Edge Seeds-v_circ"
   306,  2449,  2672,  3179,  3360,  3376,  3400,  3752,  4962,  5002,  5641,  5643,  7903,  8455,  8459,  8636
  8656,  8678,  9535, 10211, 11092, 12920, 13143, 13659, 13848, 13863, 13889, 14787, 15440, 15474, 16006, 18146
 18367, 18874, 18881, 19068, 19091, 19965, 20658, 20678, 20938, 21347, 23387, 23605, 24101, 24107, 24274, 24294
 24696, 25236, 25940, 26833, 28616, 28828, 29353, 29356, 29533, 29551, 29572, 31185, 31205
*Nset, nset="Edge Seeds-v_edge1"
     8,     9,    11,    12,    27,    28,    30,    31,    46,    47,    49,    50,    65,    66,    68,    69
    84,    85,    87,    88,   103,   104,   106,   107,   328,   329,   419,   420,   863,   864,   954,   955
  1398,  1399,  1489,  1490,  1933,  1934,  2024,  2025,  2468,  2469,  2559,  2560,  3003,  3004,  3094,  3095
 11268, 16132, 17856, 17867, 17868, 18005, 19893, 25989, 26095, 26137, 26196, 26197, 27523, 32625, 34020, 34316
 34326, 34439, 36385, 37459, 42224, 42540, 42542, 42617, 44279, 49098, 50754, 50760, 50765, 50892, 54072, 57468
 58981, 58984, 58987, 59130
*Elset, elset="Edge Seeds-v_edge1"
   366,   573,  2452,  4323,  4339,  4340,  4997,  5187,  5695,  5706,  9303,  9546,  9778, 10206, 10208, 10209
 10784, 10982, 12925, 14220, 14784, 14806, 15466, 15511, 16191, 16277, 16526, 19465, 20020, 20021, 20520, 20670
 21326, 21357, 23398, 25253, 25277, 25284, 25935, 25989, 27031, 27264, 28813, 30539, 30541, 30546, 31198, 31284
** Section: Vf
*Solid Section, elset=Set-1, material=DM60_exp1_Hyp1-Vi-10a
,
*End Part
**
*Part, name=Ring_0625
*Node
      1,          30.,           0.,           0.
      2,         -30.,           0.,           0.
      3,         -30.,       -1.875,           0.
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*Element, type=C3D4
   1, 3025, 1779, 3026, 1775
   2, 3025, 3027, 1779, 1780
   3, 3028, 3029, 1846, 1722
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*Nset, nset=Set-1, generate
    1,  4104,     1
*Elset, elset=Set-1, generate
     1,  14190,      1
** Section: RINGS
*Solid Section, elset=Set-1, material=VeroBlack_exp2_ELPL
,
*End Part
**
**
** ASSEMBLY
**
*Assembly, name=Assembly
**
*Instance, name=Ring_0625-1, part=Ring_0625
*End Instance
**
*Instance, name=Kcyl_n6UC_th075wh150thd125_eq_OP-1, part=Kcyl_n6UC_th075wh150thd125_eq_OP
*End Instance
**
*Instance, name=Kcyl_n6UC_th075wh150thd125_eq_P-1, part=Kcyl_n6UC_th075wh150thd125_eq_P
*End Instance
**
*Instance, name=Kcyl_n6UC_th075wh150thd125_eq_f-1, part=Kcyl_n6UC_th075wh150thd125_eq_f
*End Instance
**
*Instance, name=Kcyl_n6UC_th075wh150thd125_eq_v-1, part=Kcyl_n6UC_th075wh150thd125_eq_v
*End Instance
**
*Node
      1,           0.,       -1.875,           0.
*Node
      2,           0.,       54.375,           0.
*Nset, nset=m_Set-1
 1,
*Nset, nset=m_Set-2
 2,
*Elset, elset=_OP_M_S3, internal, instance=Kcyl_n6UC_th075wh150thd125_eq_OP-1
    21,    25,   115,   120,   145,   147,   161,   165,   190,   198,   225,   239,   252,   288,   291,   305
   382,   391,   618,   672,   808,   819,   827,   901,   942,   944,  1046,  1185,  1186,  1208,  1309,  1352
  1397,  1398,  1408,  1464,  1468,  1491,  1523,  1526,  1543,  1545,  1546,  1547,  1550,  1567,  1569,  1627
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*Elset, elset=_OP_M_S3, internal, instance=Kcyl_n6UC_th075wh150thd125_eq_f-1
    52,   370,   525,   526,   532,  1164,  1303,  1457,  1458,  1465,  1936,  2263,  2411,  2413,  2417,  2951
  3365,  3378,  3385,  3546,  3905,  4199,  4281,  4491,  4576,  4845,  4859,  5059,  5448,  6085,  6186,  6409
  6418,  6473,  6762,  6964,  7167,  7369,  7710,  7951,  8308,  8402,  8410,  8596,  8914,  9056,  9058,  9064
  9536,  9852, 10003, 10011, 10652, 10794, 10940, 10945
*Elset, elset=_OP_M_S4, internal, instance=Kcyl_n6UC_th075wh150thd125_eq_OP-1
    55,    93,   104,   106,   277,   287,   535,   652,   670,   778,   928,   943,   958,  1192,  1403,  1452
  1555,  1557,  1574,  1819,  2312,  2419,  2494,  2520,  2754,  2762,  2780,  2822,  2853,  2979,  2992,  3006
  3035,  3063,  3078,  3166,  3202,  3209,  3212,  3213,  3229,  3277,  3366,  3755,  3781,  3784,  3809,  3833
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*Elset, elset=_OP_M_S4, internal, instance=Kcyl_n6UC_th075wh150thd125_eq_f-1
    45,    65,   528,   991,  1006,  2402,  2416,  3366,  3373,  3525,  4556,  5093,  5094,  5263,  6241,  7095
  7102,  7190,  8006,  8008,  8607,  8644,  9996,  9998, 10006, 10010, 10013, 10476, 10499, 10932, 10944
*Elset, elset=_OP_M_S2, internal, instance=Kcyl_n6UC_th075wh150thd125_eq_OP-1
   316,   536,  1559,  1560,  1669,  2188,  2236,  2478,  2665,  2669,  2679,  2726,  2732,  2734,  2740,  2771
  2782,  2783,  2793,  2811,  2858,  2872,  2994,  2998,  3022,  3025,  3028,  3032,  3038,  3045,  3057,  3061
  3071,  3082,  3083,  3090,  3121,  3131,  3141,  3149,  3160,  3168,  3170,  3176,  3188,  3191,  3196,  3234
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*Elset, elset=_OP_M_S2, internal, instance=Kcyl_n6UC_th075wh150thd125_eq_f-1
   286,   534,  1222,  1461,  1467,  2175,  2419,  2635,  2636,  3360,  3367,  3593,  3988,  4306,  4313,  4553
  4864,  5256,  5262,  5266,  5830,  6226,  6227,  6233,  6748,  7170,  7177,  7186,  7772,  8119,  8127,  8132
  8829,  9060,  9066, 10246, 10247, 10709, 10941, 10973
*Elset, elset=_OP_M_S1, internal, instance=Kcyl_n6UC_th075wh150thd125_eq_OP-1
    20,   182,   316,   603,   722,   883,  1531,  1553,  1644,  2239,  2386,  2427,  2615,  2730,  2733,  2735
  2739,  2747,  2752,  2774,  2805,  2840,  2850,  2857,  2859,  2948,  2965,  2983,  3011,  3024,  3044,  3060
  3085,  3098,  3101,  3108,  3159,  3163,  3177,  3179,  3182,  3199,  3215,  3220,  3242,  3256,  3259,  3266
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*Elset, elset=_OP_M_S1, internal, instance=Kcyl_n6UC_th075wh150thd125_eq_f-1
   224,   372,  1168,  1305,  2110,  2892,  4019,  4198,  4796,  5749,  6079,  6700,  7652,  8767,  8916,  9708
 10654,
*Surface, type=ELEMENT, name=OP_M
_OP_M_S3, S3
_OP_M_S4, S4
_OP_M_S2, S2
_OP_M_S1, S1
*Elset, elset=_PVF_S_S3, internal, instance=Kcyl_n6UC_th075wh150thd125_eq_P-1
    41,    80,   110,   241,   246,   293,   318,   333,   338,   369,   423,   455,   459,   471,   492,   506
   512,   532,   537,   560,   561,   586,   590,   616,   626,   647,   673,   688,   704,   725,   726,   750
   752,   835,   836,   842,   939,   976,  1028,  1030,  1060,  1061,  1131,  1176,  1241,  1292,  1295,  1296
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*Elset, elset=_PVF_S_S3, internal, instance=Kcyl_n6UC_th075wh150thd125_eq_f-1
    36,    55,    60,    70,    79,   100,   141,   150,   171,   182,   204,   339,   381,   388,   389,   395
   401,   402,   406,   408,   409,   420,   424,   425,   426,   432,   448,   452,   459,   460,   467,   468
   473,   482,   490,   494,   495,   499,   500,   505,   511,   512,   521,   530,   539,   540,   541,   542
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*Elset, elset=_PVF_S_S3, internal, instance=Kcyl_n6UC_th075wh150thd125_eq_v-1
    20,    26,    27,    29,    83,   167,   281,   296,   310,   338,   376,   415,   428,   479,   574,   613
   669,   741,   820,   860,   862,   867,   884,  1007,  1044,  1104,  1120,  1122,  1198,  1200,  1201,  1244
  1273,  1276,  1300,  1308,  1318,  1329,  1334,  1340,  1377,  1438,  1451,  1460,  1486,  1491,  1528,  1529
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*Elset, elset=_PVF_S_S1, internal, instance=Kcyl_n6UC_th075wh150thd125_eq_P-1
   237,   264,   275,   868,  1109,  1269,  1375,  1393,  1487,  1655,  1666,  1754,  1782,  1811,  1929,  1941
  1947,  1976,  1985,  1988,  2001,  2014,  2030,  2043,  2057,  2117,  2157,  2167,  2193,  2218,  2226,  2229
  2242,  2329,  2367,  2377,  2402,  2459,  2492,  2496,  2509,  2533,  2570,  2617,  2652,  2654,  2657,  2660
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*Elset, elset=_PVF_S_S1, internal, instance=Kcyl_n6UC_th075wh150thd125_eq_f-1
    34,   585,   592,   605,   674,   681,   727,   861,   862,   917,   924,   937,   976,  1416,  1423,  1438
  1470,  1525,  1533,  1587,  1618,  1625,  1669,  1776,  1790,  1796,  1819,  1850,  1862,  1879,  1880,  1941
  2245,  2268,  2371,  2485,  2527,  2561,  2623,  2743,  2759,  2778,  2784,  2809,  2818,  2994,  3022,  3443
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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*Surface, type=ELEMENT, name=PVF_S
_PVF_S_S3, S3
_PVF_S_S1, S1
_PVF_S_S4, S4
_PVF_S_S2, S2
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*Surface, type=ELEMENT, name=Ring_Bottom_M1
_Ring_Bottom_M1_S3, S3
_Ring_Bottom_M1_S2, S2
_Ring_Bottom_M1_S4, S4
_Ring_Bottom_M1_S1, S1
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*Surface, type=ELEMENT, name=Ring_Bottom_S1
_Ring_Bottom_S1_S4, S4
_Ring_Bottom_S1_S3, S3
_Ring_Bottom_S1_S2, S2
_Ring_Bottom_S1_S1, S1
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*Surface, type=ELEMENT, name=Ring_Top_M2
_Ring_Top_M2_S3, S3
_Ring_Top_M2_S2, S2
_Ring_Top_M2_S4, S4
_Ring_Top_M2_S1, S1
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*Surface, type=ELEMENT, name=Ring_Top_S2
_Ring_Top_S2_S3, S3
_Ring_Top_S2_S1, S1
_Ring_Top_S2_S4, S4
_Ring_Top_S2_S2, S2
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*Surface, type=ELEMENT, name=s_Surf-3
_s_Surf-3_S3, S3
_s_Surf-3_S2, S2
_s_Surf-3_S4, S4
_s_Surf-3_S1, S1
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*Surface, type=ELEMENT, name=s_Surf-4
_s_Surf-4_S3, S3
_s_Surf-4_S2, S2
_s_Surf-4_S4, S4
_s_Surf-4_S1, S1
** Constraint: Constraint-1
*Coupling, constraint name=Constraint-1, ref node=m_Set-1, surface=s_Surf-3
*Kinematic
** Constraint: Constraint-2
*Coupling, constraint name=Constraint-2, ref node=m_Set-2, surface=s_Surf-4
*Kinematic
** Constraint: OP_PVF
*Tie, name=OP_PVF, adjust=yes, type=SURFACE TO SURFACE
PVF_S, OP_M
** Constraint: Ring_Bottom
*Tie, name=Ring_Bottom, adjust=yes, type=SURFACE TO SURFACE
Ring_Bottom_S1, Ring_Bottom_M1
** Constraint: Ring_Top
*Tie, name=Ring_Top, adjust=yes, type=SURFACE TO SURFACE
Ring_Top_S2, Ring_Top_M2
*End Assembly
*Amplitude, name=Amp-1, definition=SMOOTH STEP
             0.,              0.,              1.,              1.
*Amplitude, name="Amp-2 visc", definition=SMOOTH STEP
             0.,              0.,             18.,              1.
**
** MATERIALS
**
*Material, name=AG30_exp1_Hyp1
*Density
 1.14e-06,
*Hyperelastic, neo hooke, test data input
*Uniaxial Test Data
         0., 0.000114011
 0.00145139, 0.000433514
 0.00293056, 0.000953707
    0.00375,  0.00145183
  0.0048125,  0.00195311
 0.00586806,  0.00245439
  0.0069375,  0.00295567
 0.00769444,   0.0034601
 0.00841667,  0.00396552
 0.00896528,  0.00446266
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*Material, name=AG30_exp1_Hyp1-20
*Density
 1.14e-06,
*Hyperelastic, neo hooke, test data input
*Uniaxial Test Data
     0., 0.000114011
 0.0012, 0.000433514
 0.0023, 0.000953707
  0.003,  0.00145183
 0.0039,  0.00195311
 0.0047,  0.00245439
 0.0056,  0.00295567
 0.0062,   0.0034601
 0.0067,  0.00396552
 0.0072,  0.00446266
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*Material, name=AG30_exp1_Hyp1-Vi-20
*Density
 1.14e-06,
*Hyperelastic, neo hooke, test data input, moduli=LONG TERM
*Uniaxial Test Data
     0., 0.000114011
 0.0012, 0.000433514
 0.0023, 0.000953707
  0.003,  0.00145183
 0.0039,  0.00195311
 0.0047,  0.00245439
 0.0056,  0.00295567
 0.0062,   0.0034601
 0.0067,  0.00396552
 0.0072,  0.00446266
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*Viscoelastic, time=PRONY
  0.030377,      0., 7.61977
 0.0518769,      0., 64.3588
 0.0449821,      0.,  333.61
 0.0304131,      0., 2310.42
*Material, name=AG30_exp1_Hyp1-Vi_P4
*Density
 1.14e-06,
*Hyperelastic, neo hooke, test data input, moduli=LONG TERM
*Uniaxial Test Data
         0., 0.000114011
 0.00145139, 0.000433514
 0.00293056, 0.000953707
    0.00375,  0.00145183
  0.0048125,  0.00195311
 0.00586806,  0.00245439
  0.0069375,  0.00295567
 0.00769444,   0.0034601
 0.00841667,  0.00396552
 0.00896528,  0.00446266
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*Viscoelastic, time=PRONY
  0.030377,      0., 7.61977
 0.0518769,      0., 64.3588
 0.0449821,      0.,  333.61
 0.0304131,      0., 2310.42
*Material, name=DABS_exp1_ELPL
*Density
 1.17e-06,
*Elastic
 1911.69, 0.4
*Plastic
 24.9666,          0.
 25.6324, 8.50585e-05
  53.638,  0.00693865
 55.8437,     0.16207
*Material, name=DM60_exp1_Hyp1
*Density
 1.14e-06,
*Hyperelastic, neo hooke, test data input
*Uniaxial Test Data
 0.0007, 0.0004
 0.0008, 0.0009
  0.001, 0.0014
 0.0016, 0.0019
 0.0026, 0.0024
 0.0034, 0.0029
 0.0042, 0.0034
 0.0048, 0.0038
 0.0054, 0.0043
  0.006, 0.0048
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*Material, name=DM60_exp1_Hyp1-20
*Density
 1.14e-06,
*Hyperelastic, neo hooke, test data input
*Uniaxial Test Data
 0.0005, 0.0004
 0.0006, 0.0009
 0.0008, 0.0014
 0.0013, 0.0019
 0.0021, 0.0024
 0.0027, 0.0029
 0.0033, 0.0034
 0.0038, 0.0038
 0.0043, 0.0043
 0.0048, 0.0048
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*Material, name=DM60_exp1_Hyp1-40
*Density
 1.14e-06,
*Hyperelastic, neo hooke, test data input
*Uniaxial Test Data
 0.0004, 0.0004
 0.0005, 0.0009
 0.0006, 0.0014
  0.001, 0.0019
 0.0016, 0.0024
  0.002, 0.0029
 0.0025, 0.0034
 0.0029, 0.0038
 0.0032, 0.0043
 0.0036, 0.0048
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*Material, name=DM60_exp1_Hyp1-Vi-10a
*Density
 1.14e-09,
*Hyperelastic, neo hooke, test data input, moduli=LONG TERM
*Uniaxial Test Data
 0.0005, 0.0004
 0.0006, 0.0009
 0.0007, 0.0014
 0.0012, 0.0019
 0.0019, 0.0024
 0.0024, 0.0029
  0.003, 0.0034
 0.0034, 0.0038
 0.0039, 0.0043
 0.0043, 0.0048
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*Viscoelastic, time=PRONY
 0.0346364,      0., 10.3506
 0.0552141,      0., 98.3903
 0.0479654,      0., 547.864
 0.0411206,      0., 4151.02
*Material, name=DM60_exp1_Hyp1-Vi-20
*Density
 1.14e-06,
*Hyperelastic, neo hooke, test data input, moduli=LONG TERM
*Uniaxial Test Data
 0.0005, 0.0004
 0.0006, 0.0009
 0.0008, 0.0014
 0.0013, 0.0019
 0.0021, 0.0024
 0.0027, 0.0029
 0.0033, 0.0034
 0.0038, 0.0038
 0.0043, 0.0043
 0.0048, 0.0048
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*Viscoelastic, time=PRONY
 0.0346364,      0., 10.3506
 0.0552141,      0., 98.3903
 0.0479654,      0., 547.864
 0.0411206,      0., 4151.02
*Material, name=DM60_exp1_Hyp1-Vi_P4
*Density
 1.14e-06,
*Hyperelastic, neo hooke, test data input, moduli=LONG TERM
*Uniaxial Test Data
 0.0007, 0.0004
 0.0008, 0.0009
  0.001, 0.0014
 0.0016, 0.0019
 0.0026, 0.0024
 0.0034, 0.0029
 0.0042, 0.0034
 0.0048, 0.0038
 0.0054, 0.0043
  0.006, 0.0048
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*Viscoelastic, time=PRONY
 0.0346364,      0., 10.3506
 0.0552141,      0., 98.3903
 0.0479654,      0., 547.864
 0.0411206,      0., 4151.02
*Material, name=DM60_exp1_Hyp1-Vi_P4-Yeoh
*Density
 1.14e-06,
*Hyperelastic, yeoh, test data input, moduli=LONG TERM
*Uniaxial Test Data
 0.0007, 0.0004
 0.0008, 0.0009
  0.001, 0.0014
 0.0016, 0.0019
 0.0026, 0.0024
 0.0034, 0.0029
 0.0042, 0.0034
 0.0048, 0.0038
 0.0054, 0.0043
  0.006, 0.0048
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*Viscoelastic, time=PRONY
 0.0346364,      0., 10.3506
 0.0552141,      0., 98.3903
 0.0479654,      0., 547.864
 0.0411206,      0., 4151.02
*Material, name=DM60_exp1_Hyp1-Yeoh
*Density
 1.14e-06,
*Hyperelastic, yeoh, test data input
*Uniaxial Test Data
 0.0007, 0.0004
 0.0008, 0.0009
  0.001, 0.0014
 0.0016, 0.0019
 0.0026, 0.0024
 0.0034, 0.0029
 0.0042, 0.0034
 0.0048, 0.0038
 0.0054, 0.0043
  0.006, 0.0048
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*Material, name=DM70_exp1_Hyp2
*Density
 1.14e-06,
*Hyperelastic, neo hooke, test data input
*Uniaxial Test Data
 0.00017, 0.0003
 0.00048, 0.0004
 0.00125, 0.0005
 0.00193, 0.0006
 0.00227, 0.0011
 0.00255, 0.0016
 0.00313,  0.002
  0.0037, 0.0024
 0.00423, 0.0031
 0.00477, 0.0035
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*Material, name=DM70_exp1_Hyp2-20
*Density
 1.14e-06,
*Hyperelastic, neo hooke, test data input
*Uniaxial Test Data
 0.0001, 0.0003
 0.0004, 0.0004
  0.001, 0.0005
 0.0015, 0.0006
 0.0018, 0.0011
  0.002, 0.0016
 0.0025,  0.002
  0.003, 0.0024
 0.0034, 0.0031
 0.0038, 0.0035
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*Material, name=DM70_exp1_Hyp2-Vi-20
*Density
 1.14e-06,
*Hyperelastic, neo hooke, test data input, moduli=LONG TERM
*Uniaxial Test Data
 0.0001, 0.0003
 0.0004, 0.0004
  0.001, 0.0005
 0.0015, 0.0006
 0.0018, 0.0011
  0.002, 0.0016
 0.0025,  0.002
  0.003, 0.0024
 0.0034, 0.0031
 0.0038, 0.0035
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*Viscoelastic, time=PRONY
 0.0600823,      0.,  10.717
 0.0992267,      0., 93.9801
 0.0898734,      0., 498.891
 0.0886581,      0., 3632.45
*Material, name=DM70_exp1_Hyp2-Vi_P4
*Density
 1.14e-06,
*Hyperelastic, neo hooke, test data input, moduli=LONG TERM
*Uniaxial Test Data
 0.00017, 0.0003
 0.00048, 0.0004
 0.00125, 0.0005
 0.00193, 0.0006
 0.00227, 0.0011
 0.00255, 0.0016
 0.00313,  0.002
  0.0037, 0.0024
 0.00423, 0.0031
 0.00477, 0.0035
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*Viscoelastic, time=PRONY
 0.0600823,      0.,  10.717
 0.0992267,      0., 93.9801
 0.0898734,      0., 498.891
 0.0886581,      0., 3632.45
*Material, name=DM85_exp1_Hyp1
*Density
 1.14e-06,
*Hyperelastic, neo hooke, test data input
*Uniaxial Test Data, smooth=5
       0., 6.21118e-05
    0.008, 0.000415671
  0.01325, 0.000986622
  0.06875,   0.0023509
 0.134875,  0.00531249
   0.1965,  0.00952305
  0.26325,    0.013972
 0.323333,   0.0189135
    0.376,   0.0235666
    0.419,   0.0283181
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*Material, name=DM85_exp1_Hyp1-Vi_20n
*Density
 1.14e-06,
*Hyperelastic, neo hooke, test data input, moduli=LONG TERM
*Uniaxial Test Data, smooth=5
       0., 6.21118e-05
  0.00256, 0.000415671
  0.00424, 0.000986622
    0.022,   0.0023509
  0.04316,  0.00531249
  0.06288,  0.00952305
  0.08424,    0.013972
 0.103467,   0.0189135
  0.12032,   0.0235666
  0.13408,   0.0283181
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*Viscoelastic, time=PRONY
 0.070967,      0., 10.7874
 0.131463,      0., 78.8478
 0.130833,      0., 404.112
 0.146487,      0., 3116.46
*Material, name=DM85_exp1_Hyp1-Vi_20n-Yeoh
*Density
 1.14e-06,
*Hyperelastic, yeoh, test data input, moduli=LONG TERM
*Uniaxial Test Data, smooth=5
       0., 6.21118e-05
  0.00256, 0.000415671
  0.00424, 0.000986622
    0.022,   0.0023509
  0.04316,  0.00531249
  0.06288,  0.00952305
  0.08424,    0.013972
 0.103467,   0.0189135
  0.12032,   0.0235666
  0.13408,   0.0283181
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*Viscoelastic, time=PRONY
 0.070967,      0., 10.7874
 0.131463,      0., 78.8478
 0.130833,      0., 404.112
 0.146487,      0., 3116.46
*Material, name=DM85_exp1_Hyp1-Vi_P4
*Density
 1.14e-06,
*Hyperelastic, neo hooke, test data input, moduli=LONG TERM
*Uniaxial Test Data, smooth=5
       0., 6.21118e-05
    0.008, 0.000415671
  0.01325, 0.000986622
  0.06875,   0.0023509
 0.134875,  0.00531249
   0.1965,  0.00952305
  0.26325,    0.013972
 0.323333,   0.0189135
    0.376,   0.0235666
    0.419,   0.0283181
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*Viscoelastic, time=PRONY
 0.070967,      0., 10.7874
 0.131463,      0., 78.8478
 0.130833,      0., 404.112
 0.146487,      0., 3116.46
*Material, name=DM85_exp1_Hyp1-Vi_P4-Yeoh
*Density
 1.14e-06,
*Hyperelastic, yeoh, test data input, moduli=LONG TERM
*Uniaxial Test Data, smooth=5
       0., 6.21118e-05
    0.008, 0.000415671
  0.01325, 0.000986622
  0.06875,   0.0023509
 0.134875,  0.00531249
   0.1965,  0.00952305
  0.26325,    0.013972
 0.323333,   0.0189135
    0.376,   0.0235666
    0.419,   0.0283181
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*Viscoelastic, time=PRONY
 0.070967,      0., 10.7874
 0.131463,      0., 78.8478
 0.130833,      0., 404.112
 0.146487,      0., 3116.46
*Material, name=DM85_exp1_Hyp1-n40
*Density
 1.14e-06,
*Hyperelastic, neo hooke, test data input
*Uniaxial Test Data, smooth=5
       0., 6.21118e-05
   0.0032, 0.000415671
   0.0053, 0.000986622
   0.0275,   0.0023509
  0.05395,  0.00531249
   0.0786,  0.00952305
   0.1053,    0.013972
 0.129333,   0.0189135
   0.1504,   0.0235666
   0.1676,   0.0283181
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*Material, name=DM85_exp1_Hyp1-n40-20
*Density
 1.14e-06,
*Hyperelastic, neo hooke, test data input
*Uniaxial Test Data, smooth=5
       0., 6.21118e-05
  0.00256, 0.000415671
  0.00424, 0.000986622
    0.022,   0.0023509
  0.04316,  0.00531249
  0.06288,  0.00952305
  0.08424,    0.013972
 0.103467,   0.0189135
  0.12032,   0.0235666
  0.13408,   0.0283181
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*Material, name=DM85_exp1_Hyp1-n40-Yeoh
*Density
 1.14e-06,
*Hyperelastic, yeoh, test data input
*Uniaxial Test Data, smooth=5
       0., 6.21118e-05
   0.0032, 0.000415671
   0.0053, 0.000986622
   0.0275,   0.0023509
  0.05395,  0.00531249
   0.0786,  0.00952305
   0.1053,    0.013972
 0.129333,   0.0189135
   0.1504,   0.0235666
   0.1676,   0.0283181
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*Material, name=DM95_exp1_Hyp1
*Density
 1.14e-06,
*Hyperelastic, neo hooke, test data input
*Uniaxial Test Data, smooth=5
         0., 2.46853e-05
 0.00916667, 0.000185139
  0.0247778, 0.000394022
  0.0452778, 0.000755726
  0.0746667,  0.00143532
   0.124222,   0.0020507
   0.161444,  0.00307087
      0.202,  0.00384445
   0.234889,   0.0048727
   0.273222,  0.00563978
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*Material, name=DM95_exp1_Hyp1-Vi_20n
*Density
 1.14e-06,
*Hyperelastic, neo hooke, test data input, moduli=LONG TERM
*Uniaxial Test Data, smooth=5
        0., 2.46853e-05
    0.0044, 0.000185139
 0.0118933, 0.000394022
 0.0217333, 0.000755726
   0.03584,  0.00143532
 0.0596267,   0.0020507
 0.0774933,  0.00307087
   0.09696,  0.00384445
  0.112747,   0.0048727
  0.131147,  0.00563978
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*Viscoelastic, time=PRONY
 0.143438,      0., 11.4351
  0.18857,      0.,  93.977
 0.153513,      0., 520.646
 0.137152,      0., 3697.45
*Material, name=DM95_exp1_Hyp1-Vi_20n-Yeoh
*Density
 1.14e-06,
*Hyperelastic, yeoh, test data input, moduli=LONG TERM
*Uniaxial Test Data, smooth=5
        0., 2.46853e-05
    0.0044, 0.000185139
 0.0118933, 0.000394022
 0.0217333, 0.000755726
   0.03584,  0.00143532
 0.0596267,   0.0020507
 0.0774933,  0.00307087
   0.09696,  0.00384445
  0.112747,   0.0048727
  0.131147,  0.00563978
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*Viscoelastic, time=PRONY
 0.143438,      0., 11.4351
  0.18857,      0.,  93.977
 0.153513,      0., 520.646
 0.137152,      0., 3697.45
*Material, name=DM95_exp1_Hyp1-Vi_P4
*Density
 1.14e-06,
*Hyperelastic, neo hooke, test data input, moduli=LONG TERM
*Uniaxial Test Data, smooth=5
         0., 2.46853e-05
 0.00916667, 0.000185139
  0.0247778, 0.000394022
  0.0452778, 0.000755726
  0.0746667,  0.00143532
   0.124222,   0.0020507
   0.161444,  0.00307087
      0.202,  0.00384445
   0.234889,   0.0048727
   0.273222,  0.00563978
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*Viscoelastic, time=PRONY
 0.143438,      0., 11.4351
  0.18857,      0.,  93.977
 0.153513,      0., 520.646
 0.137152,      0., 3697.45
*Material, name=DM95_exp1_Hyp1-Yeoh
*Density
 1.14e-06,
*Hyperelastic, yeoh, test data input
*Uniaxial Test Data, smooth=5
         0., 2.46853e-05
 0.00916667, 0.000185139
  0.0247778, 0.000394022
  0.0452778, 0.000755726
  0.0746667,  0.00143532
   0.124222,   0.0020507
   0.161444,  0.00307087
      0.202,  0.00384445
   0.234889,   0.0048727
   0.273222,  0.00563978
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*Material, name=DM95_exp1_Hyp1-n40
*Density
 1.14e-06,
*Hyperelastic, neo hooke, test data input
*Uniaxial Test Data, smooth=5
        0., 2.46853e-05
    0.0055, 0.000185139
 0.0148667, 0.000394022
 0.0271667, 0.000755726
    0.0448,  0.00143532
 0.0745333,   0.0020507
 0.0968667,  0.00307087
    0.1212,  0.00384445
  0.140933,   0.0048727
  0.163933,  0.00563978
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*Material, name=DM95_exp1_Hyp1-n40-20
*Density
 1.14e-06,
*Hyperelastic, neo hooke, test data input
*Uniaxial Test Data, smooth=5
        0., 2.46853e-05
    0.0044, 0.000185139
 0.0118933, 0.000394022
 0.0217333, 0.000755726
   0.03584,  0.00143532
 0.0596267,   0.0020507
 0.0774933,  0.00307087
   0.09696,  0.00384445
  0.112747,   0.0048727
  0.131147,  0.00563978
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*Material, name=DM95_exp1_Hyp1-n40-20-Yeoh
*Density
 1.14e-06,
*Hyperelastic, yeoh, test data input
*Uniaxial Test Data, smooth=5
        0., 2.46853e-05
    0.0044, 0.000185139
 0.0118933, 0.000394022
 0.0217333, 0.000755726
   0.03584,  0.00143532
 0.0596267,   0.0020507
 0.0774933,  0.00307087
   0.09696,  0.00384445
  0.112747,   0.0048727
  0.131147,  0.00563978
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*Material, name=DM95_exp1_Hyp1-n40-Yeoh
*Density
 1.14e-06,
*Hyperelastic, neo hooke, test data input
*Uniaxial Test Data, smooth=5
        0., 2.46853e-05
    0.0055, 0.000185139
 0.0148667, 0.000394022
 0.0271667, 0.000755726
    0.0448,  0.00143532
 0.0745333,   0.0020507
 0.0968667,  0.00307087
    0.1212,  0.00384445
  0.140933,   0.0048727
  0.163933,  0.00563978
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** DM Arruda Boyce model- , Jiang, 2020
** 3D printed tubular lattice metamaterials with engineered mechanical
** performance
*Material, name=FLX95595-DM1
*Density
 1.2e-06,
*Hyperelastic, arruda-boyce
 1.85, 5.713,  0.02
*Material, name=VeroBlack_exp1_ELPL
*Density
 1.17e-06,
*Elastic
 1345.87, 0.4
*Plastic
 19.7978,          0.
 19.8647, 1.62653e-05
 33.2684,  0.00473062
 35.3406,   0.0738715
 35.8976,    0.174468
*Material, name=VeroBlack_exp1_ELPL+20p
*Density
 1.17e-06,
*Elastic
 1852.47, 0.4
*Plastic
 49.1831,          0.
 49.4986, 0.000148512
 43.0105,   0.0954356
*Material, name=VeroBlack_exp2_ELPL
*Density
 1.17e-09,
*Elastic
 1543.35, 0.4
*Plastic
 19.3844,          0.
 19.7219, 4.81795e-05
 36.8447,    0.122367
*Material, name=VeroYellow_exp1
*Density
 1.17e-06,
*Elastic
 989.688, 0.4
*Plastic
 15.0334,          0.
 15.1914, 5.16991e-05
 20.8704,  0.00229191
 26.5493,  0.00727848
 29.6441,   0.0446374
 30.2143,   0.0910225
** ----------------------------------------------------------------
**
** STEP: Step-1
**
*Step, name=Step-1, nlgeom=YES, inc=500
*Visco, cetol=0.01
0.18, 18., 1e-06, 1.8
**
** BOUNDARY CONDITIONS
**
** Name: BC-1 Type: Displacement/Rotation
*Boundary, amplitude="Amp-2 visc"
m_Set-1, 1, 1
m_Set-1, 2, 2
m_Set-1, 3, 3
m_Set-1, 4, 4
m_Set-1, 5, 5
m_Set-1, 6, 6
** Name: BC-2 Type: Displacement/Rotation
*Boundary, amplitude="Amp-2 visc"
m_Set-2, 1, 1
m_Set-2, 2, 2, -18.
m_Set-2, 3, 3
**
** OUTPUT REQUESTS
**
*Restart, write, frequency=0
**
** FIELD OUTPUT: F-Output-1
**
*Output, field, variable=PRESELECT
**
** HISTORY OUTPUT: H-Output-1
**
*Output, history, variable=PRESELECT
*End Step
